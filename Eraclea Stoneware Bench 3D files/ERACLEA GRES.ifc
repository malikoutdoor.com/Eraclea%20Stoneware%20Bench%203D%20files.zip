Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2023-10-31T11:47:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 31 11:47:10 2023 * Host: LAPTOP-RP8DN0OA * Database: C:\Users\claud\AppData\Local\Temp\{CA4F46C2-1CE6-49EA-8CFB-DF31067BB5F8}\ifc * Database version: 5507 * Database creation date: Tue Oct 31 11:47:09 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 31 11:47:10 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 31 11:47:10 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey, 0 - Piano Terra
LongName: 0 - Piano Terra; Elevation: 0 m
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello: Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello; Famiglia e tipo: Livello: Livello; ID tipo: Livello: Livello; Tipo: Livello: Livello
Dati identità - Nome: 0 - Piano Terra; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 m
Vincoli - Quota altimetrica: 0 m
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello

# IfcBuildingElementProxy: 0PAAR066 - GRANITO, Panca ERACLEA GRES:0PAAR066 - GRANITO:141430
In: 0 - Piano Terra
Type - Material: GRES, GRANITO
Type - Altro - Categoria: Modelli generici; Nome famiglia: Panca ERACLEA GRES
Type - Dati identità - BIM Name: ERACLEA GRES; BIM Object Type: Panchine - Benches; Code: 0PAAR066; Designer: BELLITALIA DESIGN; Family Name: ERACLEA; Nome del tipo: 0PAAR066 - GRANITO; URL Eng: https://www.bellitalia.net/en/products/benches/eraclea-gres/; URL Ita: https://www.bellitalia.net/prodotti/panchine/eraclea-gres/
Type - Dimensioni - Dimensions: 2200 mm x 610 mm x 450 mm
Type - Generale - Accessori: 1 striscia LED; Accessories: 1 LED strip; Descrizione Tecnica Famiglia: "Panca lineare mod. “ERACLEA” GRES, costituita da una base di supporto alleggerita allo scopo di creare la sede per la predisposizione di un rivestimento in gres. Sezione longitudinale a C permette l'appoggio su due supporti alle estremità contenendone il peso totale."; Descrizione Tecnica per Codice: PANCA IN GRES ERACLEA IN GRANITO (COLORE A SCELTA) SABBIATA; Fissaggio: Appoggio; Fixings: freestanding; Technical Description Family: "Linear bench mod. ""ERACLEA"" GRES, established by a lightened support base in order to create the seat for the preparation of a gres covering."; Technical Description for Article: ERACLEA STONEWARE BENCH IN GRANITE (COLOR OF YOUR CHOICE) SANDBLASTED WITH BRUSHED UPPER CIRCLES, ANTI-DECADENT PAINT AND STONEWARE (COLOR FROM CHOICE) LOCATION
Type - Materiali e finiture - Materiale Principale: Granito Bianco; Materiale Secondario: Pietre di Granito; Gres; MATERIALE SEDUTA: GRES; MATERIALE SUPPORTO: GRANITO; Primary Material: White granite; Secondary Material: Reconstituted Precious Stone; Gres
Type - Meccanica - Weight ( kg): 601 Kg
Pset_BuildingElementProxyCommon - Reference: 0PAAR066 - GRANITO
Altro - Famiglia: Panca ERACLEA GRES: 0PAAR066 - GRANITO; Famiglia e tipo: Panca ERACLEA GRES: 0PAAR066 - GRANITO; ID tipo: Panca ERACLEA GRES: 0PAAR066 - GRANITO; Tipo: Panca ERACLEA GRES: 0PAAR066 - GRANITO
Dimensioni - Area: 3.44389 m2; Volume: 0.217229 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Host: Livello : 0 - Piano Terra; Livello: Livello: 0 - Piano Terra; Offset: 0 m; Sposta con l'oggetto più vicino: no
